# Keil uVision project elejrjc.simuinput.uvprojx, settings and files
target rtx5simu (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: elejrjc.simuinput
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xE, USE_HAL_DRIVER
  c include: .\user;.\firmware\inc;.\firmware\inc\Legacy;.\rtt
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c hal_main.c Thread.c USBD_User_CustomClass_0.c WinUSB_Echo.c
  group firmware
    ./firmware/src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_pcd.c stm32f1xx_ll_usb.c stm32f1xx_hal_pcd_ex.c
  group rtt
    ./rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS:Keil RTX5 5.3.0, CMSIS:RTOS2:Keil RTX5 5.4.0, USB:CORE 6.12.8, USB:Device 6.12.8, USB:Device:Custom Class 6.12.8, CMSIS Driver:USART 2.2, CMSIS Driver:USB Device 2.0, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0
